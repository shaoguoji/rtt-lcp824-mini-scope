# Keil uVision project LPC824.uvprojx, settings and files
target LPC824 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC824_OLED_SSD1306_ +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: .\Libraries\Common;.\Drivers;.\Libraries\Common\board;.\Libraries\Common\chip;.\Libraries\Common\CMSIS;.\Libraries\Common\startup;.\applications;.\rt-thread\components\finsh;.\rt-thread\include;..\firmware;.\board;.\miniscope;.\board\oled
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Applications
    ./applications/: main.c
  group Libraries
    ./Libraries/Common/board/: board.c
    ./Libraries/Common/chip/: clock_8xx.c ioswm_8xx.c syscon_8xx.c sysinit_8xx.c
    ./Libraries/Common/startup/: keil_startup_lpc82x.s
  group Drivers
    ./Drivers/uart/: ring_buffer.c uart_8xx.c
    ./Drivers/adc/: adc_8xx.c
  group rt-thread
    ./rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ./rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ./rt-thread/components/finsh/: cmd.c msh.c shell.c
  group board
    ./board/: board.c drv_adc.c
    ./board/oled/: oled.c
  group miniscope
    ./miniscope/: display.c miniscope.c wavedata.c
